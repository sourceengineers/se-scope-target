# Keil uVision project scope-lib.uvprojx, settings and files
target debug-STM32-G071 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: scope-lib-stm32-g0 (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: ARCH_SIZE_32=1
  c include: ..\public\;..\include\Scope\;..\3rdparty\nanopb\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Communication
    ../src/Communication/Interfaces/: FramedIO.c
  group Control
    ../src/Control/: CommandParserDispatcher.c Controller.c CommandPackParserDispatcher.c AnnounceStorage.c ParserDefinitions.c
    ../src/Control/Commands/Command/: CommandAddr.c CommandAnnounce.c CommandClear.c CommandDetect.c CommandPoll.c CommandRunning.c CommandTInc.c CommandTrans.c CommandTrigger.c
    ../src/Control/Commands/CommandParser/: CommandAddrParser.c CommandAnnounceParser.c CommandClearParser.c CommandDetectParser.c CommandPollParser.c CommandRunningParser.c CommandTIncParser.c CommandTransParser.c CommandTriggerParser.c
    ../src/Control/PackCommands/Command/: CommandPackAnnounce.c CommandPackData.c
    ../src/Control/PackCommands/CommandParser/: CommandPackAnnounceParser.c CommandPackDataParser.c
  group Core
    ../src/Core/: Channel.c Scope.c Timestamper.c Trigger.c
  group GeneralPurpose
    ../src/GeneralPurpose/: BufferedByteStream.c BufferedFloatStream.c BufferedIntStream.c ByteRingBuffer.c FloatRingBuffer.c IntRingBuffer.c
  group Serialisation
    ../src/Serialisation/: Serializer.c
    ../src/Serialisation/JsonParser/: JsonPacker.c
    ../src/Serialisation/Protobuf/: NanopbPacker.c se-scope.pb.c NanopbUnpacker.c
    ../3rdparty/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Builder
    ../src/Builders/: ScopeBuilder.c ScopeRunner.c ScopeThreadRunner.c ScopeFramedStack.c
target debug-STM32-F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: scope-lib-stm32-f407 (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: ARCH_SIZE_32=1
  c include: ..\public\;..\include\Scope\;..\3rdparty\jsmn\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target debug-STM32-F107 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: scope-lib-stm32-f107 (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: ARCH_SIZE_32=1
  c include: ..\public\;..\include\Scope\;..\3rdparty\jsmn\
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
